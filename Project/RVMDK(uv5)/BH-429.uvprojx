# Keil uVision project BH-429.uvprojx, settings and files
target BH-F429 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BH-F429 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\uCOS_III\uC-CPU;..\..\uCOS_III\uC-LIB;..\..\uCOS_III\uCOS-III\Ports;..\..\uCOS_III\uCOS-III\Source;..\..\USER\os_cfg;..\..\USER\App;..\..\USER\Bsp\ETH;..\..\USER\lwip-1.4.1\port;..\..\USER\lwip-1.4.1\port\arch;..\..\USER\lwip-1.4.1\port\UCOS305;..\..\USER\lwip-1.4.1\src\include;..\..\USER\lwip-1.4.1\src\include\ipv4;..\..\USER\lwip-1.4.1\src\include\lwip;..\..\USER\lwip-1.4.1\src\netif;..\..\USER\FATFS;..\..\USER\Server;..\..\USER\sdio;..\..\USER\FATFS\option;..\..\USER\Bsp\Timer;..\..\USER\Bsp\led;..\..\..\00ArtNet;..\..\ArtNet;..\..\USER\Server;..\..\USER\Bsp\key;..\..\USER\Bsp\usart;..\..\USER\Server;..\..\USER\sdram;..\..\USER\Bsp\wm8978;..\..\USER\Bsp;..\..\USER\STM32F10x_DSP_Lib\inc;..\..\USER\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../USER/App/: netconf.c
    ../../USER/: main.c stm32f4xx_it.c
  group App
    ../../ArtNet/: ArtNet.c
    ../../USER/App/: fileApp.c App.c NetworkDHCP.c
  group BSP
    ../../USER/Bsp/key/: bsp_key.c
    ../../USER/Bsp/led/: bsp_led.c
    ../../USER/Bsp/usart/: bsp_debug_usart.c
    ../../USER/Bsp/ETH/: stm32f429_eth.c stm32f429_phy.c
    ../../USER/Bsp/: bsp.c cpu_bsp.c
    ../../USER/sdio/: bsp_sdio_sd.c
    ../../USER/Bsp/Timer/: bsp_time.c hal_time.c
    ../../USER/sdram/: bsp_sdram.c
    ../../USER/Bsp/wm8978/: bsp_wm8978.c bsp_sound.c
  group ArtNet
    ../../ArtNet/: ArtControl.c ArtDMX.c ArtIpProg.c ArtPoll.c ArtRDM.c Display.c DmxOut.c ArtMem.c ArtNetScreen.c
  group Model
    ../../ArtNet/: Model.c Model_Normal.c Model_Normal_Soft.c Model_Normal_Romatic.c Model_Normal_Breath.c Model_Normal_HeartBeat.c Model_KTV.c Model_KTV_Soft.c Model_KTV_Romatic.c Model_KTV_Rythem.c Model_KTV_Dynamic.c Model_Techo.c Model_Techo_DubStep.c Model_Techo_Trance.c Model_Techo_Electp.c Model_Techo_DeepHouse.c
  group Server
    ../../USER/Server/: Server.c RecordFile.c IList.c TimerServer.c Keyboard.c SinTable.c MathBase.c
    ../../USER/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s
    ../../USER/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group FATTS
    ../../USER/FATFS/: ff.c diskio.c
    ../../USER/FATFS/option/: cc936.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCOSIII_CPU
    ../../uCOS_III/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOSIII_LIB
    ../../uCOS_III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOSIII_Source
    ../../uCOS_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII_Port
    ../../uCOS_III/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group os_cfg
    ../../USER/os_cfg/: cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group LwIP_src_api
    ../../USER/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_src_core_ipv4
    ../../USER/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP_src_core
    ../../USER/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_src_netif
    ../../USER/lwip-1.4.1/src/netif/: etharp.c
  group LwIP_port
    ../../USER/lwip-1.4.1/port/UCOS305/: ethernetif.c sys_arch.c
  group DOC
    ../../: 必读说明.txt
